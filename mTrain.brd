# Repository RoboJackets/mtrain-pcb

File README.md:

# MCU Board

PCB for STM32F769NIH6 microcontroller. This board is still a work in progress but most of the major components exist and are connected to the MCU. Major components include:
* Microcontroller: STM32F769NIH6
* Flash memory: S25FS256SAGNFI00
* SDRAM: MT48LC16M16A2F4
* USB HS interface: USB3315C
* Ethernet 100/10 interface: LAN8742A

This board is currently only four layers but should be updated to six in a future revision and impedances should be calculated on the traces that matter.

VBAT is currently unused but should be added in to take advantage of the RTC that is on the board.

There is a space for a pull up and pull down resistor on the BOOT pin on the MCU. Only one of these should be populated (by default the pull down should be populated).

OTG functionality is not used with the USB HS interface because that would require a 5V source on the board. A future revision may add this but currently this feature is unneeded.

The four bottom LEDs are connected directly to pins on the MCU but only two of them are connected to PWM pins due to routing constraints. This should be fixed upon moving to 6 layers. The LED next to the button is currently simply used to indicate power, it may be desired to change this in the future to indicate some status of the MCU.

The button labeled USB MODE will be used to toggle the MCU into a state that will show the device as a USB mass storage device, displaying the contents of the flash chip. The LED next to it is used to indicate if it is in this UMS mode.

The power is passed from the USB or the VIN to a buck converter to allow for 4.5V to 24V input with the buck outputing ~3.5V which gets fed into a linear regulator to drop the voltage to 3.3V. The buck is in place for an efficient conversion then the LDO is in place to make sure the power is smoothed out before it is distributed to the sensitive chips.

#### Before modifying ensure layout changes are in compliance with datasheets

<!--  -->

## EAGLE design mTrain.brd

Parts:
C1, C2: 4.7pF; C0402
C3, C5: 2.2uF; C0402
C4, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C26, C27: 0.1uF; C0402
C24, C28: 4.7uF; C0402
C25: 1uF; C0402
L1: BLM15AG601SN1D; 0402
R1, R2, R4, R6: 10k; R0402
R3: 100; R0402
R5: [NA]; R0402
U1: STM32F769NIH6; TFBGA216
X1: G83270021
X2: DSC6101JI2A-025.0000; DSC6101JI2A

Connections:
!RST: R4.1, U1.J1 (NRST); also elsewhere on the board
BOOT: R5.1, R6.1, U1.E6 (BOOT0)
BUTTON-USB: U1.D15 (PA10); also elsewhere on the board
BYPASS-REG: R2.2, U1.L5 (BYPASS_REG)
ETH-DV: U1.R3 (PA7); also elsewhere on the board
ETH-MDC: U1.M3 (PC1); also elsewhere on the board
ETH-MDIO: U1.P2 (PA2); also elsewhere on the board
ETH-REF_CLK: U1.N2 (PA1); also elsewhere on the board
ETH-RXD0: U1.N5 (PC4); also elsewhere on the board
ETH-RXD1: U1.P5 (PC5); also elsewhere on the board
ETH-RXER: U1.D5 (PI10); also elsewhere on the board
ETH-TXD0: U1.B3 (PG13); also elsewhere on the board
ETH-TXD1: U1.A4 (PG14); also elsewhere on the board
ETH-TX_EN: U1.B8 (PG11); also elsewhere on the board
FMC-A0: U1.D2 (PF0); also elsewhere on the board
FMC-A1: U1.E2 (PF1); also elsewhere on the board
FMC-A2: U1.G2 (PF2); also elsewhere on the board
FMC-A3: U1.H2 (PF3); also elsewhere on the board
FMC-A4: U1.J2 (PF4); also elsewhere on the board
FMC-A5: U1.K3 (PF5); also elsewhere on the board
FMC-A6: U1.M6 (PF12); also elsewhere on the board
FMC-A7: U1.N6 (PF13); also elsewhere on the board
FMC-A8: U1.P6 (PF14); also elsewhere on the board
FMC-A9: U1.M8 (PF15); also elsewhere on the board
FMC-A10: U1.N7 (PG0); also elsewhere on the board
FMC-A11: U1.M7 (PG1); also elsewhere on the board
FMC-A12: U1.M13 (PG2); also elsewhere on the board
FMC-BA0: U1.N12 (PG4); also elsewhere on the board
FMC-BA1: U1.N11 (PG5); also elsewhere on the board
FMC-D0: U1.L12 (PD14); also elsewhere on the board
FMC-D1: U1.K13 (PD15); also elsewhere on the board
FMC-D2: U1.B12 (PD0); also elsewhere on the board
FMC-D3: U1.C12 (PD1); also elsewhere on the board
FMC-D4: U1.R8 (PE7); also elsewhere on the board
FMC-D5: U1.N9 (PE8); also elsewhere on the board
FMC-D6: U1.P9 (PE9); also elsewhere on the board
FMC-D7: U1.R9 (PE10); also elsewhere on the board
FMC-D8: U1.P10 (PE11); also elsewhere on the board
FMC-D9: U1.R10 (PE12); also elsewhere on the board
FMC-D10: U1.R12 (PE13); also elsewhere on the board
FMC-D11: U1.P11 (PE14); also elsewhere on the board
FMC-D12: U1.R11 (PE15); also elsewhere on the board
FMC-D13: U1.L15 (PD8); also elsewhere on the board
FMC-D14: U1.L14 (PD9); also elsewhere on the board
FMC-D15: U1.K15 (PD10); also elsewhere on the board
FMC-LDQM: U1.A6 (PE0); also elsewhere on the board
FMC-SDCKE0: U1.K4 (PH2); also elsewhere on the board
FMC-SDCLK: U1.H14 (PG8); also elsewhere on the board
FMC-SDNCAS: U1.B7 (PG15); also elsewhere on the board
FMC-SDNE0: U1.J4 (PH3); also elsewhere on the board
FMC-SDNRAS: U1.P8 (PF11); also elsewhere on the board
FMC-SDNWE: U1.J3 (PH5); also elsewhere on the board
FMC-UDQM: U1.A5 (PE1); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, R2.1, R6.2, U1.F2 (VSS), U1.F6 (VSS), U1.F7 (VSS), U1.F8 (VSS), U1.F9 (VSS), U1.F10 (VSS), U1.G6 (VSS), U1.G10 (VSS), U1.G12 (VSSDSI), U1.H6 (VSS), U1.H10 (VSS), U1.J6 (VSS), U1.J10 (VSS), U1.K6 (VSS), U1.K7 (VSS), U1.K8 (VSS), U1.K9 (VSS), U1.K10 (VSS), U1.L6 (VSS), U1.M1 (VSSA), U1.N1 (VREF-), X2.2 (GND); also elsewhere on the board
JTDI: U1.A13 (PA15/JTDI); also elsewhere on the board
LED1: U1.B1 (PE5); also elsewhere on the board
LED2: U1.A2 (PE3); also elsewhere on the board
LED3: U1.B2 (PE6); also elsewhere on the board
LED4: U1.A1 (PE4); also elsewhere on the board
LED-USB: U1.E15 (PA9); also elsewhere on the board
MCU-OSC: R3.2, U1.G1 (PH0/OSC_IN)
OSC32-IN: C1.1, U1.E1 (PC14/OSC32_IN), X1.2
OSC32-OUT: C2.1, U1.F1 (PC15/OSC32_OUT), X1.1
OSC-25M: R3.1, X2.3 (OUT); also elsewhere on the board
OTG_HS-CK: U1.P4 (PA5); also elsewhere on the board
OTG_HS-D0: U1.R2 (PA3); also elsewhere on the board
OTG_HS-D1: U1.R5 (PB0); also elsewhere on the board
OTG_HS-D2: U1.R4 (PB1); also elsewhere on the board
OTG_HS-D3: U1.P12 (PB10); also elsewhere on the board
OTG_HS-D4: U1.R13 (PB11); also elsewhere on the board
OTG_HS-D5: U1.L13 (PB12); also elsewhere on the board
OTG_HS-D6: U1.K14 (PB13); also elsewhere on the board
OTG_HS-D7: U1.A8 (PB5); also elsewhere on the board
OTG_HS-DIR: U1.M4 (PC2); also elsewhere on the board
OTG_HS-NXT: U1.L4 (PC3); also elsewhere on the board
OTG_HS-STP: U1.M2 (PC0); also elsewhere on the board
OUT-A1: U1.K2 (PF6); also elsewhere on the board
OUT-A2: U1.K1 (PF7); also elsewhere on the board
OUT-A3: U1.L3 (PF8); also elsewhere on the board
OUT-A4: U1.L2 (PF9); also elsewhere on the board
OUT-B1: U1.C15 (PA11); also elsewhere on the board
OUT-B2: U1.B15 (PA12); also elsewhere on the board
OUT-B3: U1.R14 (PB14); also elsewhere on the board
OUT-B4: U1.R15 (PB15); also elsewhere on the board
OUT-B5: U1.F15 (PA8); also elsewhere on the board
OUT-C1: U1.A7 (PB8); also elsewhere on the board
OUT-C2: U1.B4 (PB9); also elsewhere on the board
OUT-D1: U1.B6; also elsewhere on the board
OUT-D2: U1.B5 (PB7); also elsewhere on the board
OUT-E1: U1.A12 (PC12); also elsewhere on the board
OUT-E2: U1.A9 (PB4/NJTRST); also elsewhere on the board
OUT-E3: U1.B14 (PC10); also elsewhere on the board
OUT-E4: U1.N4 (PA4); also elsewhere on the board
OUT-F1: U1.H15 (PC6); also elsewhere on the board
OUT-F2: U1.G15 (PC7); also elsewhere on the board
OUT-F3: U1.G14 (PC8); also elsewhere on the board
OUT-F4: U1.F14 (PC9); also elsewhere on the board
OUT-G1: U1.P15 (PH10); also elsewhere on the board
OUT-G2: U1.N15 (PH11); also elsewhere on the board
OUT-G3: U1.M15 (PH12); also elsewhere on the board
OUT-G4: U1.E14 (PI0); also elsewhere on the board
OUT-H1: U1.C10 (PD5); also elsewhere on the board
OUT-H2: U1.B11 (PD6); also elsewhere on the board
OUT-H3: U1.A11 (PD7); also elsewhere on the board
OUT-Z1: U1.N3 (PA0/WKUP); also elsewhere on the board
OUT-Z2: U1.P3 (PA6); also elsewhere on the board
PDR-ON: R1.2, U1.E5 (PDR_ON)
QSPI-!CS: U1.B13 (PC11); also elsewhere on the board
QSPI-CLK: U1.M5 (PB2); also elsewhere on the board
QSPI-D0: U1.N10 (PD11); also elsewhere on the board
QSPI-D1: U1.M10 (PD12); also elsewhere on the board
QSPI-D2: U1.A3 (PE2); also elsewhere on the board
QSPI-D3: U1.M11 (PD13); also elsewhere on the board
SWCLK: U1.A14 (PA14/JTCK/SWCLK); also elsewhere on the board
SWDIO: U1.A15 (PA13/JTMS/SWDIO); also elsewhere on the board
SWO: U1.A10 (PB3/JTDO/TRACESWO); also elsewhere on the board
VCAP1: C3.1, U1.L11 (VCAP_1)
VCAP2: C5.1, U1.E11 (VCAP_2)
VDD: C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C26.1, C28.1, L1.2, R1.1, R4.2, R5.2, U1.C1 (VBAT), U1.E7 (VDD), U1.E8 (VDD), U1.E9 (VDDSDMMC), U1.E10 (VDD), U1.F4 (VDD), U1.F5 (VDD), U1.F11 (VDD), U1.G5 (VDD), U1.G11 (VDDUSB), U1.H5 (VDD), U1.H11 (VDDDSI), U1.J5 (VDD), U1.J11 (VDD), U1.K5 (VDD), U1.K11 (VDD), U1.L7 (VDD), U1.L8 (VDD), U1.L9 (VDD), U1.L10 (VDD), X2.4 (VDD); also elsewhere on the board
VDD12DSI: U1.G13 (VDD12DSI), U1.K12 (VCAPDSI)
VDDA: C4.1, C25.1, C27.1, L1.1, U1.P1 (VREF+), U1.R1 (VDDA)

Notes on the sheet:
Place as close as possible to VDD/VSS pair
Ceramic capacitors (low ESR < 2 ohm)
OE pulled high internally
VDDSI connected to power VDD12DSI connected to VCAPDSI 2.2uF cap on VCAPDSI if used 0.1uF cap on supply VSSDSI connected to gnd

Parts:
C29, C32, C33, C34, C36, C38, C39, C40, C41, C46, C47, C48, C49, C50, C51, C52: 0.1uF; C0402
C30: 470pF; C0402
C31, C44, C45: 1uF; C0402
C35, C37: 10uF; C0402
C42: 2.2uF; C0402
C43: 4.7uF 10V; C0603
J1: UX60-MB-5S8
L2: BLM15PX121SN1D; 0402
R7, R8, R9, R11: 33; R0402
R10: 10k; R0402
R12, R14, R15, R16, R17: 4.7k; R0402
R13, R22: 100; R0402
R18, R20, R21, R23: 49.9; R0402
R19: 12.1k 1%; R0402
R24: 8.06k 1%; R0402
R25: 820; R0402
U2: S25FS256SAGNFI00; WSON8
U3: LAN8742A; VQFN24
U4: USB3315C; VQFN24
U5: MIC5503-1.8YMT-TR
U6: MT48LC16M16A2F4; VFBGA54
X3: DSC6101JI2A-024.0000; DSC6101JI2A

Connections:
1.8V: C38.1, C44.1, U4.21 (VDD1.8), U5.1 (VOUT)
!RST: U3.15 (!RST), U4.22 (RESETB); also elsewhere on the board
ETH-DV: R9.1; also elsewhere on the board
ETH-DV-P: R9.2, R17.1, U3.11 (CRS_DV)
ETH-MDC: U3.13 (MDC); also elsewhere on the board
ETH-MDIO: R11.1, U3.12 (MDIO); also elsewhere on the board
ETH-OSC: R13.1, U3.5 (XTAL1/CLKIN)
ETH-RBIAS: R19.2, U3.24 (RBIAS)
ETH-REF_CLK: R12.1, U3.14 (!INT); also elsewhere on the board
ETH-RXD0: R7.1; also elsewhere on the board
ETH-RXD0_P: R7.2, R14.1, U3.8 (RXD0)
ETH-RXD1: R8.1; also elsewhere on the board
ETH-RXD1_P: R8.2, R15.1, U3.7 (RXD1)
ETH-RXER: R16.2, U3.10 (RXER); also elsewhere on the board
ETH-RX_N: R18.1, U3.22 (RXN); also elsewhere on the board
ETH-RX_P: R20.1, U3.23 (RXP); also elsewhere on the board
ETH-TXD0: U3.17 (TXD0); also elsewhere on the board
ETH-TXD1: U3.18 (TXD1); also elsewhere on the board
ETH-TX_EN: U3.16 (TXEN); also elsewhere on the board
ETH-TX_N: R21.1, U3.20 (TXN); also elsewhere on the board
ETH-TX_P: R23.1, U3.21 (TXP); also elsewhere on the board
ETH-VDDA: C32.1, C33.1, C35.1, L2.1, U3.1 (VDD2A), U3.19 (VDD1A)
ETH-VDDCR: C30.1, C31.1, U3.6 (VDDCR)
FMC-A0: U6.H7 (A0); also elsewhere on the board
FMC-A1: U6.H8 (A1); also elsewhere on the board
FMC-A2: U6.J8 (A2); also elsewhere on the board
FMC-A3: U6.J7 (A3); also elsewhere on the board
FMC-A4: U6.J3 (A4); also elsewhere on the board
FMC-A5: U6.J2 (A5); also elsewhere on the board
FMC-A6: U6.H3 (A6); also elsewhere on the board
FMC-A7: U6.H2 (A7); also elsewhere on the board
FMC-A8: U6.H1 (A8); also elsewhere on the board
FMC-A9: U6.G3 (A9); also elsewhere on the board
FMC-A10: U6.H9 (A10); also elsewhere on the board
FMC-A11: U6.G2 (A11); also elsewhere on the board
FMC-A12: U6.G1 (A12); also elsewhere on the board
FMC-BA0: U6.G7 (BA0); also elsewhere on the board
FMC-BA1: U6.G8 (BA1); also elsewhere on the board
FMC-D0: U6.C9 (DQ3); also elsewhere on the board
FMC-D1: U6.B9 (DQ1); also elsewhere on the board
FMC-D2: U6.B8 (DQ2); also elsewhere on the board
FMC-D3: U6.A8 (DQ0); also elsewhere on the board
FMC-D4: U6.E9 (DQ7); also elsewhere on the board
FMC-D5: U6.C8 (DQ4); also elsewhere on the board
FMC-D6: U6.D8 (DQ6); also elsewhere on the board
FMC-D7: U6.D9 (DQ5); also elsewhere on the board
FMC-D8: U6.D2 (DQ9); also elsewhere on the board
FMC-D9: U6.E1 (DQ8); also elsewhere on the board
FMC-D10: U6.C1 (DQ12); also elsewhere on the board
FMC-D11: U6.C2 (DQ11); also elsewhere on the board
FMC-D12: U6.D1 (DQ10); also elsewhere on the board
FMC-D13: U6.A2 (DQ15); also elsewhere on the board
FMC-D14: U6.B2 (DQ13); also elsewhere on the board
FMC-D15: U6.B1 (DQ14); also elsewhere on the board
FMC-LDQM: U6.E8 (LDQM); also elsewhere on the board
FMC-SDCKE0: U6.F3 (CKE); also elsewhere on the board
FMC-SDCLK: U6.F2 (CLK); also elsewhere on the board
FMC-SDNCAS: U6.F7 (!CAS); also elsewhere on the board
FMC-SDNE0: U6.G9 (!CS); also elsewhere on the board
FMC-SDNRAS: U6.F8 (!RAS); also elsewhere on the board
FMC-SDNWE: U6.F9 (!WE); also elsewhere on the board
FMC-UDQM: U6.F1 (UDQM); also elsewhere on the board
GND: C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, J1.5, R16.1, R19.1, R24.1, U2.4 (VSS), U3.FLAG (GND), U4.FLAG (GND), U5.2 (GND), U6.A1 (VSS), U6.A3 (VSSQ), U6.B7 (VSSQ), U6.C3 (VSSQ), U6.D7 (VSSQ), U6.E3 (VSS), U6.J1 (VSS), X3.2 (GND); also elsewhere on the board
OSC-24M: R22.1, X3.3 (OUT)
OSC-25M: R13.2; also elsewhere on the board
OTG_HS-CK: U4.12 (CLKOUT); also elsewhere on the board
OTG_HS-D0: U4.16 (DATA0); also elsewhere on the board
OTG_HS-D1: U4.15 (DATA1); also elsewhere on the board
OTG_HS-D2: U4.14 (DATA2); also elsewhere on the board
OTG_HS-D3: U4.13 (DATA3); also elsewhere on the board
OTG_HS-D4: U4.11 (DATA4); also elsewhere on the board
OTG_HS-D5: U4.10 (DATA5); also elsewhere on the board
OTG_HS-D6: U4.9 (DATA6); also elsewhere on the board
OTG_HS-D7: U4.8 (DATA7); also elsewhere on the board
OTG_HS-DIR: U4.19 (DIR); also elsewhere on the board
OTG_HS-NXT: U4.18 (NXT); also elsewhere on the board
OTG_HS-STP: U4.20 (STP); also elsewhere on the board
QSPI-!CS: R10.2, U2.1 (CS); also elsewhere on the board
QSPI-CLK: U2.6 (SCK); also elsewhere on the board
QSPI-D0: U2.5 (SI/IO0); also elsewhere on the board
QSPI-D1: U2.2 (SO/IO1); also elsewhere on the board
QSPI-D2: U2.3 (WP/IO2); also elsewhere on the board
QSPI-D3: U2.7 (RESET/IO3); also elsewhere on the board
USB-3.3V: C41.1, C42.1, U4.4 (VDD3.3)
USB-D_N: J1.2, U4.5 (DM)
USB-D_P: J1.3, U4.6 (DP)
USB-RBIAS: R24.2, U4.24 (RBIAS)
USB-REFCLK: R22.2, U4.23 (REFCLK)
USB-VBUS: R25.2, U4.2 (VBUS)
VBUS: C43.1, J1.1, R25.1; also elsewhere on the board
VDD: C29.1, C34.1, C36.1, C37.1, C39.1, C40.1, C45.1, C46.1, C47.1, C48.1, C49.1, C50.1, C51.1, C52.1, L2.2, R10.1, R11.2, R12.2, R14.2, R15.2, R17.2, R18.2, R20.2, R21.2, R23.2, U2.8 (VCC), U3.9 (VDDIO), U4.3 (VBAT), U4.17 (VDDIO), U5.3 (EN), U5.4 (VIN), U6.A7 (VDDQ), U6.A9 (VDD), U6.B3 (VDDQ), U6.C7 (VDDQ), U6.D3 (VDDQ), U6.E7 (VDD), U6.J9 (VDD), X3.4 (VDD); also elsewhere on the board

Notes on the sheet:
Quad SPI Flash Memory
Ethernet PHY
SDRAM
USB HS Interface

Parts:
C53: 10uF 50V; C1206
C54: 22uF 10V; C0603
C55, C56: 1uF; C0402
C57, C58: 0.1uF; C0402
D1: PMEG3020CPA,115; SOT1061
D2, D3, D4, D5, D6: BLUE; CHIP-LED0603
D7: GREEN; CHIP-LED0603
J2: JTAG-MINI; FTSH-105-01-F-D-K
JP1, JP2: PINHD-1X20; 1X20
R26: 56k; R0402
R27: 100k; R0402
R28: 160k 1%; R0402
R29: 47k 1%; R0402
R30, R31, R32, R33, R34, R35: 330; R0402
S1: EVQ-P7C01P
S2: EVP-BFAC1A000
U7: MPM3620GQV-P
U8: NCP186AMX330TAG; XDFN8

Connections:
!RST: C58.1, J2.10 (!RST), JP2.4, S2.A' (A2); also elsewhere on the board
BUTTON-USB: C57.1, S1.2' (B2); also elsewhere on the board
ETH-RX_N: JP2.18; also elsewhere on the board
ETH-RX_P: JP2.17; also elsewhere on the board
ETH-TX_N: JP2.20; also elsewhere on the board
ETH-TX_P: JP2.19; also elsewhere on the board
GND: C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, D2.C (K), D3.C (K), D4.C (K), D5.C (K), D6.C (K), D7.C (K), J2.3 (GND), J2.5 (GND), JP1.1, R26.1, R29.1, S1.1' (A2), S2.B (B1), U7.3 (AGND), U7.12 (PGND), U7.13 (PGND), U7.14 (PGND), U8.3 (NC), U8.5 (GND), U8.9 (NC); also elsewhere on the board
JTDI: J2.8 (TDI); also elsewhere on the board
LED1: R30.2; also elsewhere on the board
LED1-PRE: D2.A, R30.1
LED2: R32.2; also elsewhere on the board
LED2-PRE: D4.A, R32.1
LED3: R31.2; also elsewhere on the board
LED3-PRE: D3.A, R31.1
LED4: R33.2; also elsewhere on the board
LED4-PRE: D5.A, R33.1
LED-USB: R34.2; also elsewhere on the board
LED-USB-PRE: D6.A, R34.1
LED-VDD-PRE: D7.A, R35.1
OUT-A1: JP2.11; also elsewhere on the board
OUT-A2: JP2.12; also elsewhere on the board
OUT-A3: JP2.13; also elsewhere on the board
OUT-A4: JP2.14; also elsewhere on the board
OUT-B1: JP1.7; also elsewhere on the board
OUT-B2: JP1.6; also elsewhere on the board
OUT-B3: JP1.5; also elsewhere on the board
OUT-B4: JP1.4; also elsewhere on the board
OUT-B5: JP1.3; also elsewhere on the board
OUT-C1: JP1.20; also elsewhere on the board
OUT-C2: JP1.19; also elsewhere on the board
OUT-D1: JP2.16; also elsewhere on the board
OUT-D2: JP2.15; also elsewhere on the board
OUT-E1: JP2.5; also elsewhere on the board
OUT-E2: JP2.6; also elsewhere on the board
OUT-E3: JP2.7; also elsewhere on the board
OUT-E4: JP2.8; also elsewhere on the board
OUT-F1: JP1.8; also elsewhere on the board
OUT-F2: JP1.9; also elsewhere on the board
OUT-F3: JP1.10; also elsewhere on the board
OUT-F4: JP1.11; also elsewhere on the board
OUT-G1: JP1.12; also elsewhere on the board
OUT-G2: JP1.13; also elsewhere on the board
OUT-G3: JP1.14; also elsewhere on the board
OUT-G4: JP1.15; also elsewhere on the board
OUT-H1: JP1.16; also elsewhere on the board
OUT-H2: JP1.17; also elsewhere on the board
OUT-H3: JP1.18; also elsewhere on the board
OUT-Z1: JP2.10; also elsewhere on the board
OUT-Z2: JP2.9; also elsewhere on the board
REG-AAM: R26.2, U7.18 (AAM)
REG-EN: R27.2, U7.17 (EN)
REG-FB: R28.1, R29.2, U7.1 (FB)
REG-IN: C53.1, D1.3 (C), R27.1, U7.16 (IN)
REG-OUT: C54.1, C55.1, R28.2, U7.789 (OUT), U8.6 (EN), U8.7 (IN), U8.8 (IN)
REG-SW: U7.456 (SW)
SWCLK: J2.4 (SWCLK/TCK); also elsewhere on the board
SWDIO: J2.2 (SWIO/TMS); also elsewhere on the board
SWO: J2.6 (SWO/TDO); also elsewhere on the board
VBUS: D1.1 (A1), JP2.2; also elsewhere on the board
VDD: C56.1, J2.1 (VCC), JP2.1, R35.2, U8.1 (OUT), U8.2 (OUT), U8.4 (FB); also elsewhere on the board
VIN: D1.2 (A2), JP1.2

Notes on the sheet:
JTAG Mini Connector
Should output ~3.515V
Power
Not connected on purpose
Reset Button
USB mass storage mode button
DIP Out
LEDs and Buttons

Board: 6 copper layers, 25.6 x 53.5 mm, 120 parts (60 on the bottom side), 153 nets.

Other parts of the board:
U$1: ROBOBUZZ_0.4X

## Commit log

2018-05-11 Add HAL files and start of build system
2018-07-03 Fix VDDDSI connection issue
2018-07-03 Change DRC for PCBWay 6 layer
2018-07-03 Move board to bare minimum for 6 layer
2018-07-06 Start 6 layer routing
2018-07-22 continue routing breakout
2018-08-28 6 layer no DRC errors
2018-09-13 v0.2 and pin numbers
2018-09-13 fix error
2018-09-23 fix drc annular ring
2018-10-26 working light blink
2018-10-30 move
2019-04-10 minor changes for v1.0
2020-05-18 Quick cleanup
2020-05-18 Updated gitignore and README
2020-05-18 Renamed mchair library to mtrain
2020-05-18 Adjusted library to remove not used symbols and footprints
2020-06-29 Create LICENSE
